# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Lib\CMSIS;..\Lib\STM32F10x_StdPeriph_Driver\Inc;..\BSP\Dev\Inc;..\BSP\MCU\Inc;..\Inc;..\Utils\Inc;..\App\Core\Inc;..\App\UI\Core\Inc;..\Test\Inc;..\App\UI\Page\Home\Inc;..\App\UI\Page\Setting\Inc;..\App\UI\Page\Menu\Inc;..\App\UI\Page\StopWatch\Inc;..\App\UI\Page\Flashlight\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/UI/Core/Src/: ui_core.c
    ../App/UI/Page/Home/Src/: ui_page_home.c
    ../App/UI/Page/Setting/Src/: ui_page_setting.c ui_page_setting_datetime.c
    ../App/Core/Src/: app.c
    ../App/UI/Page/Menu/Src/: ui_page_menu.c slide_menu.c
    ../App/UI/Page/StopWatch/Src/: ui_page_stopwatch.c
    ../App/UI/Page/Flashlight/Src/: ui_page_flashlight.c
  group BSP
    ../BSP/Dev/Src/: bsp_led.c bsp_oled.c bsp_oled_data.c bsp_key.c
    ../BSP/MCU/Src/: bsp_uart.c bsp_i2c_sw.c bsp_rtc.c bsp_sys_tick.c bsp_dwt.c
  group Core
    ../Core/: startup_stm32f10x_md.s
  group Lib
    ../Lib/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Lib/STM32F10x_StdPeriph_Driver/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Utils
    ../Utils/Src/: delay.c
  group Src
    ../Src/: main.c stm32f10x_it.c bsp_init.c
  group Test
    ../Test/Src/: test.c
